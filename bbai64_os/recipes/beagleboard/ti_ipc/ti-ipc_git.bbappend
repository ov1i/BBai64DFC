EXTRA_OECONF += "PLATFORM=AM65XX"
